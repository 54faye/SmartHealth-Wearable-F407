# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: .\User;.\Drivers\BSP;..\Drivers\BSP;..\Drivers\CMSIS;..\Drivers\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314W
  group User
    ./User/: main.c stm32f4xx_it.c
  group BSP (Bootloader)
    ./Drivers/BSP/: bsp_delay.c bsp_usart.c
  group BSP (Shared)
    ../Drivers/BSP/: bsp_spi1.c bsp_w25q128.c bsp_i2c_hw.c bsp_at24c02.c
  group CMSIS
    ../Drivers/CMSIS/: system_stm32f4xx.c
  group Startup
    ../Drivers/Startup/: startup_stm32f40xx.s
  group StdPeriph
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_pwr.c stm32f4xx_syscfg.c stm32f4xx_crc.c
